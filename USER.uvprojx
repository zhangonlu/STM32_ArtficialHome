# Keil uVision project USER.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USER +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\HARDWARE\LED;.\SYSTEM\sys;.\FreeRTOS\include;.\FreeRTOS\port;.\FreeRTOS\sys;.\SYSTEM\delay;.\SYSTEM\ringbuffer;.\HARDWARE\UART;.\HARDWARE\WIFI;.\HARDWARE\EEPROM;.\HARDWARE\dht11;.\HARDWARE\iic;.\HARDWARE\OLED;.\HARDWARE\BEEP;.\HARDWARE\KEY;.\HARDWARE\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/UART/: uart.c
    ./HARDWARE/WIFI/: wifi.c
    ./HARDWARE/dht11/: dht11.c
    ./HARDWARE/iic/: iic.c
    ./HARDWARE/OLED/: oled.c oledmenu.c
    ./HARDWARE/BEEP/: beep.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/EEPROM/: at24c02.c
    ./HARDWARE/PWM/: pwm.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/ringbuffer/: ringbuffer.c
  group FreeRTOS/Source
    ./FreeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ./FreeRTOS/port/: heap_4.c port.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.3.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
